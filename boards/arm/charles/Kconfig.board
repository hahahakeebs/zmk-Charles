## boards/arm/charles/Kconfig.board
```kconfig
# Charles board configuration

config BOARD_CHARLES
	bool "hahahakeebs Charles"
	depends on SOC_NRF52840_QIAA
```
